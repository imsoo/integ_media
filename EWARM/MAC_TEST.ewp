# IAR project MAC_TEST.ewp, settings and files
configuration MAC_TEST (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/INTEG_MAC/Inc; ../Drivers/LIFI/LIFI_MAC/Inc; ../Drivers/BLUETOOTH/BLUETOOTH_MAC/Inc; ../Drivers/CC2530/CC2530_MAC/Inc; ../Drivers/CC2530/CC2530_Common/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MAC_TEST.bin
  ILINK.IlinkOutputFile: MAC_TEST.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: display.c gpio.c hash.c list.c main.c queue.c stm32f4xx_hal_msp.c stm32f4xx_it.c task.c timer.c uart.c
    ../Drivers/INTEG_MAC/Src/: stub.c
  group Drivers/BLUETOOTH
    ../Drivers/BLUETOOTH/BLUETOOTH_MAC/Src/: bluetooth.c
  group Drivers/CC2530/CC2530_Common
    ../Drivers/CC2530/CC2530_Common/Src/: utilities.c
  group Drivers/CC2530/CC2530_MAC
    ../Drivers/CC2530/CC2530_MAC/Src/: mac_interface.c mac_interface_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/INTEG_MAC
    ../Drivers/INTEG_MAC/Src/: frame_queue.c integ_mac.c mem_pool.c
    ../Drivers/INTEG_MAC/Inc/: image.h
  group Drivers/LIFI
    ../Drivers/LIFI/LIFI_MAC/Src/: lifi.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
